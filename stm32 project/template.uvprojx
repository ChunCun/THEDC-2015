# Keil uVision project template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Core;.\STM32F10x_FWLib\inc;.\USER;.\HARDWARE;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\6050;.\SYSTEM\dma;.\HARDWARE\motor;.\HARDWARE\ccd;.\HARDWARE\ir;.\HARDWARE\god;.\HARDWARE\speed
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h
  group CORE
    ./Core/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_wwdg.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c delay.h
    ./SYSTEM/sys/: sys.c sys.h
    ./SYSTEM/usart/: usart.c usart.h uart2.c uart2.h uart3.c uart3.h
    ./SYSTEM/dma/: dma.c dma.h
  group HARDWARE
    ./HARDWARE/6050/: 6050.c 6050.h
    ./HARDWARE/motor/: motor.c motor.h pwm.c pwm.h tim2.c tim2.h
    ./HARDWARE/ccd/: adc.c adc.h ccd.c ccd.h
    ./HARDWARE/god/: god.c god.h
    ./HARDWARE/ir/: ir.c ir.h
    ./HARDWARE/: strategy.c strategy.h speed.h speed.c tim4.c tim4.h
